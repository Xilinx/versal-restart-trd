FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://ATF-PATCH-fix-plat-xilinx-versal-use-different-function-to-clear-pending-sgi-interrupts.patch"

